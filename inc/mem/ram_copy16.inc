;-----------------------------------------------------------------------------------------------------------------------
;Файл распространяется под лицензией GPL-3.0-or-later, https://www.gnu.org/licenses/gpl-3.0.txt
;-----------------------------------------------------------------------------------------------------------------------
;07.10.2019  w5277c@gmail.com        Начало
;01.08.2020  w5277c@gmail.com        Разбиение на файлы
;27.10.2020  w5277c@gmail.com        Обновлена информация об авторских правах
;-----------------------------------------------------------------------------------------------------------------------
.ifdef DEF_C5_RAM_COPY16
.else
.set DEF_C5_RAM_COPY16 = 1

;--------------------------------------------------------
C5_RAM_COPY16:
;--------------------------------------------------------
;Копирование блока памяти
;IN: X-SRC адрес, Z-DST адрес,
;TEMP_H,TEMP_L-длина(1-65535,0=65536)
;-START--------------------------------------------------
	PUSH_X
	PUSH_Z
	PUSH TEMP_H
	PUSH TEMP_L
	PUSH TEMP
_C5_RAM_COPY16__LOOP:
	LD TEMP,X+
	ST Z+,TEMP
	SUBI TEMP_L,0x01
	SBCI TEMP_H,0x00
	TST TEMP_H
	BRNE _C5_RAM_COPY16__LOOP
	TST TEMP_L
	BRNE _C5_RAM_COPY16__LOOP
	POP TEMP
	POP TEMP_L
	POP TEMP_H
	POP_Z
	POP_X
	RET
.endif
