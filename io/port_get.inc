;-----------------------------------------------------------------------------------------------------------------------
;Файл распространяется под лицензией GPL-3.0-or-later, https://www.gnu.org/licenses/gpl-3.0.txt
;-----------------------------------------------------------------------------------------------------------------------
;05.03.2020	w5277c@gmail.com			Начало
;01.08.2020	w5277c@gmail.com			Разбиение на файлы
;27.10.2020	w5277c@gmail.com			Обновлена информация об авторских правах
;05.12.2020	w5277c@gmail.com			-с5
;18.08.2021	w5277c@gmail.com			Ничего не делаем, если порт не задан(0xff)
;-----------------------------------------------------------------------------------------------------------------------
.ifdef DEF_PORT_GET
.else
.set DEF_PORT_GET = 1

.if REPORT_INCLUDES == 0x01
.message "included PORT_GET"
.endif

.include	"./io/port_offsets.inc"

;--------------------------------------------------------
PORT_GET:
;--------------------------------------------------------
;Считывание состояния порта
;IN: ACCUM-сдвоенный порт, исп. только старший ниббл
;OUT: flag С-состояние порта(true = HI)
;--------------------------------------------------------
	CPI ACCUM,0xff
	BRNE PC+0x02
	RET

	PUSH_Z
	PUSH_THL
	PUSH TEMP
	PUSH ACCUM

	MCALL PORT_OFFSETS
	MOV ZH,C0x00
	MOV ZL,TEMP
	LD TEMP,Z
	AND TEMP,ACCUM
	ADD TEMP,C0xff

	POP ACCUM
	POP TEMP
	POP_THL
	POP_Z
	RET
.endif
